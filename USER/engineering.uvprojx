# Keil uVision project engineering.uvprojx, settings and files
target ENGINEER (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: engineering.elf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,ARM_MATH_CM4,__FPU_PRESENT=1,__TARGET_FPU_VFP,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\USER_CONF;..\BSP_CONF;..\TASK;..\FUNTION;..\PROTOCOL;.\include;..\BMI088;..\BMI088\algorithm\Include;..\BMI088\devices;..\BMI088\algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c User.h stm32f4xx_it.c system_stm32f4xx.c STM32_TIM_BASE.c arm_cortexM4lf_math.lib
    ../USER_CONF/: start_task.c
  group Bsp_device
    ../BSP_CONF/: bsp_can.c bsp_flash.c bsp_trigonometry.c bsp_dwt.c bsp_dwt.h bsp_can.h bsp_vofa.c bsp_vofa.h bsp_imu.c bsp_imu.h
  group BMI088
    ../BMI088/algorithm/: AHRS_middleware.c filters.c MahonyAHRS.c AHRS.h AHRS.lib
  group Task
    ../TASK/: modeswitch_task.c comm_task.c chassis_task.c info_get_task.c detect_task.c judge_task.c controller.c motor_task.c comm_8010_task.c comm_8010_task.h imu_task.c imu_task.h
    ../PROTOCOL/: data_fifo.c
  group Protocol
    ../PROTOCOL/: protocol.c data_packet.c judge_rx_data.c judge_tx_data.c pc_rx_data.c pc_tx_data.c crc.c crc.h motor_8010.c motor_8010.h
  group Funtion
    ../TASK/: pc_task.c
    ../FUNTION/: fuzzy_pid.c kalman_filter.c keyboard.c remote_ctrl.c pid.c clamp.c power_control.c power_control.h General_function.c General_function.h Inverse_Kinematics.c Inverse_Kinematics.h
    ./: filter.c
  group User_conf
    ../USER_CONF/: delay.c gpio.c can.c usart.c spi.c rc.c dma.c tim.c sys_config.h
  group CORE
    ../CORE/: startup_stm32f427_437xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
